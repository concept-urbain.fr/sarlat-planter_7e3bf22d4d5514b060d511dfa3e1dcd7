Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Sarlat Jardinière.IFC
Time: 2020-07-03T11:20:49
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: SARL-JAR-GM-002-01_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 101.679; Area Measure: 8.54496; Volume Measure: 0.0218939

# IfcBuildingElementProxy: SARL-JAR-GM-004_Default
In: Default Storey
Material: PE

# IfcBuildingElementProxy: SARL-JAR-GM-007_Default
In: Default Storey
Material: S235 galva
